options:
  parameters:
    author: zoe
    generate_options: qt_gui
    id: test_framer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_random_0
  id: blocks_message_strobe_random
  parameters:
    dist: blocks.STROBE_UNIFORM
    mean: '1000'
    msg: pmt.intern("TEST")
    std: '1000'
  states: {}
- name: cs330project22_deinterleaver_0
  id: cs330project22_deinterleaver
  parameters:
    block_size: '96'
  states: {}
- name: cs330project22_framer_0
  id: cs330project22_framer
  parameters:
    preamble: '0xAA'
    preamble_len: '64'
    sync_word: '[0x58, 0x9A]'
  states: {}
- name: cs330project22_interleaver_0
  id: cs330project22_interleaver
  parameters:
    block_size: '96'
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    mtu: '10000'
    port: '52001'
    type: TCP_SERVER
  states: {state: disabled}
- name: pdu_random_pdu_0
  id: pdu_random_pdu
  parameters:
    length_modulo: '2'
    mask: '0xFF'
    maxsize: '2000'
    minsize: '50'
  states: {}

connections:
- [blocks_message_strobe_random_0, strobe, pdu_random_pdu_0, generate]
- [cs330project22_deinterleaver_0, pdu_out, blocks_message_debug_0, print]
- [cs330project22_framer_0, frame, cs330project22_interleaver_0, pdu_in]
- [cs330project22_interleaver_0, pdu_out, cs330project22_deinterleaver_0, pdu_in]
- [digital_crc32_async_bb_0, out, cs330project22_framer_0, pdu]
- [pdu_random_pdu_0, pdus, digital_crc32_async_bb_0, in]

metadata:
  file_format: 1
